# IAR project GPIO_Driver.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../Downloads_/Embedded Diploma Projects/Three-Mode-Application-main/Three-Mode-Application-main/Three modes Application/: common_macros.h GPIO.c GPIO.h macros.h startup_ewarm.c std_types.h tm4c123gh6pm.h Typedef.h
    ./: main.c
